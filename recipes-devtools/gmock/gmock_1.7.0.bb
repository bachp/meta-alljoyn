require gmock.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "073b984d8798ea1594f5e44d85b20d66"
SRC_URI[sha256sum] = "26fcbb5925b74ad5fc8c26b0495dfc96353f4d553492eb97e85a8a6d2f43095b"
