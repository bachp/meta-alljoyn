require uncrustify.inc

PR = "${INC_PR}.0"

SRC_URI += "file://add_missing_unistd_header.patch"

SRC_URI[md5sum] = "ef2a7228a6e92bd224f64947c9b796a6"
SRC_URI[sha256sum] = "ab0526fdc1ba0f11bbd5fc36cb3ee2bde1a9b7d105ce1f382f55c6f376f3f7aa"

