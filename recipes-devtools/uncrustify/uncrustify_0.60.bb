require uncrustify.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ec7323e54364d3e53998639237f0d375"
SRC_URI[sha256sum] = "8f97ae191b013bdc8fb6b446ffc5721704335aeb8586b61d269304b54554d01d"
